options:
  parameters:
    author: Tirado-Barrios
    copyright: UIS
    generate_options: qt_gui
    id: ModulacionPM
    output_language: python
    title: ModulacionPM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: Kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Kp
    start: '0'
    step: '0.000001'
    stop: '10'
    value: '1'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    start: '1000'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: CalculoPotencia_J1C_04_0
  id: CalculoPotencia_J1C_04
  parameters:
    l_vect: '1024'
  states: {}
- name: Envolvente_complejaPM_J1A_0
  id: Envolvente_complejaPM_J1A
  parameters:
    Ac: Ac
    Kp: Kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [Envolvente_complejaPM_J1A_0, '0', blocks_complex_to_mag_0, '0']
- [Envolvente_complejaPM_J1A_0, '0', qtgui_freq_sink_x_0, '0']
- [Envolvente_complejaPM_J1A_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', Envolvente_complejaPM_J1A_0, '0']
- [blocks_complex_to_mag_0, '0', CalculoPotencia_J1C_04_0, '0']

metadata:
  file_format: 1
