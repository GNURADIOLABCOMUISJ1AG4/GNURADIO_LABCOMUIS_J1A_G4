options:
  parameters:
    author: Barrios-Tirado
    generate_options: qt_gui
    id: Transmisor_AM
    output_language: python
    title: Transmisor_AM
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud Modulante
    start: '0'
    step: '0.00010'
    stop: '4'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.0001'
    stop: '4'
    value: '0.1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: GANANCIA TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    start: '50000000'
    step: '1000000'
    stop: '2200000000'
    value: '50000000'
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: coeficiente ka
    start: '0'
    step: '0.0001'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: CalculoPotencia_0
  id: CalculoPotencia
  parameters:
    l_vect: '1024'
  states: {}
- name: Envolvente_Compleja_DSB_SC_0
  id: Envolvente_Compleja_DSB_SC
  parameters:
    Ac: Ac
    k: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Envolvente_Compleja_DSB_SC_0, '0', blocks_complex_to_mag_0, '0']
- [Envolvente_Compleja_DSB_SC_0, '0', qtgui_freq_sink_x_0, '0']
- [Envolvente_Compleja_DSB_SC_0, '0', qtgui_time_sink_x_1, '0']
- [Envolvente_Compleja_DSB_SC_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Envolvente_Compleja_DSB_SC_0, '0']
- [blocks_complex_to_mag_0, '0', CalculoPotencia_0, '0']

metadata:
  file_format: 1
